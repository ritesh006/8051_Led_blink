# Keil uVision project led_Blinking.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89CV51RD2 NXP
  cpu: IRAM(0-0xFF) IROM(0x000-0xFFFF) XRAM(0x000-0x2FF)CLOCK(20000000) MODP2
  output: led_Blinking +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 led_Blink.c
